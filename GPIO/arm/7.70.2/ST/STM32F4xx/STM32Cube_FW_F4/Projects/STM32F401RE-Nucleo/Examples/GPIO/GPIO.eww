<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GPIO_IOToggle\EWARM\GPIO_IOToggle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GPIO_IOToggle</project>
        <configuration>STM32F4xx-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


